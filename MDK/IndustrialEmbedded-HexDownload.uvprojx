# Keil uVision project IndustrialEmbedded-HexDownload.uvprojx, settings and files
target IndustrialEmbedded_HexDownload (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: GD32F470VE GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.3.5.0
  cpu: IRAM(0x20000000,0x030000) IRAM2(0x10000000,0x010000) IROM(0x08000000,0x080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(25000000) ELITTLE
  output: IndustrialEmbedded-App-with-manifest.hex
  AfterMake: D:\keil5\ARM\ARMCC\bin\fromelf.exe --bin -o "$L@L.bin" "#L"
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F470,NDEBUG
  c include: ..\Driver\CMSIS\GD\GD32F4xx\Include;..\Driver\CMSIS;..\Libraries\Include;..\App\inc;..\BSP;..\Middleware;..\Common\inc;..\Middleware\Ringbuffer\inc;..\Middleware\Protocol\inc;..\Middleware\CLI\inc;..\Middleware\FlashKV\inc;..\Middleware\FreeRTOS\Kernel\include;..\Middleware\FreeRTOS\Kernel\portable\RVDS\ARM_CM4F;..\App\config;..\Tasks\inc;..\Middleware\Ebtn\inc;..\Middleware\FatFs\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8012000 size 0x1ffc0
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Startup
    ../Driver/CMSIS/GD/GD32F4xx/Source/ARM/: startup_gd32f450_470.s
  group CMSIS
    ../Driver/CMSIS/GD/GD32F4xx/Source/: system_gd32f4xx.c
  group Libraries
    ../Libraries/Source/: gd32f4xx_adc.c gd32f4xx_can.c gd32f4xx_crc.c gd32f4xx_ctc.c gd32f4xx_dac.c gd32f4xx_dbg.c gd32f4xx_dci.c gd32f4xx_dma.c gd32f4xx_enet.c gd32f4xx_exmc.c gd32f4xx_exti.c gd32f4xx_fmc.c gd32f4xx_fwdgt.c gd32f4xx_gpio.c gd32f4xx_i2c.c gd32f4xx_ipa.c gd32f4xx_iref.c gd32f4xx_misc.c gd32f4xx_pmu.c gd32f4xx_rcu.c gd32f4xx_rtc.c gd32f4xx_sdio.c gd32f4xx_spi.c gd32f4xx_syscfg.c gd32f4xx_timer.c gd32f4xx_tli.c gd32f4xx_trng.c gd32f4xx_usart.c gd32f4xx_wwdgt.c
  group BSP
    ../BSP/: board_config.h board_gpio.c board_usart.c board_spi_flash.c board_key.c board_i2c.c board_oled.c board_sdio.c board_dma_map.h board_adc.c board_dac.c board_rtc.c board_timebase.c
  group Middleware
    ../Middleware/CLI/src/: cli.c
    ../Middleware/Ringbuffer/src/: ringbuffer.c
    ../Middleware/Protocol/src/: protocol_frame.c modbus_rtu.c protocol_stream.c
    ../Middleware/FlashKV/src/: flash_kv.c
    ../Middleware/Ebtn/src/: ebtn.c
    ../Middleware/Ebtn/inc/: bit_array.h
    ../Middleware/FatFs/src/: diskio.c ff.c fattime.c ffsystem.c ffunicode.c
    ../Middleware/FatFs/inc/: ffconf.h
  group Common
    ../Common/src/: common_crc.c upgrade_serialization.c
    ../Common/inc/: common_flash_layout.h common_reset_contract.h
  group App/src
    ../App/src/: app_main.c gd32f4xx_it.c freertos_static.c app_config.c app_config_ini.c app_config_import.c app_cli.c app_protocol.c app_modbus.c
  group FreeRTOS/Kernel
    ../Middleware/FreeRTOS/Kernel/: event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS/Portable
    ../Middleware/FreeRTOS/Kernel/portable/RVDS/ARM_CM4F/: port.c
  group App/config
    ../App/config/: FreeRTOSConfig.h
  group Tasks
    ../Tasks/src/: protocol_task.c alarm_task.c control_task.c display_task.c health_task.c sample_task.c storage_task.c storage_persist_queue.c storage_persistence.c alarm_logic.c storage_record_format.c storage_mount_policy.c app_task.c task_queues.c task_events.c task_mutex.c task_timer.c
