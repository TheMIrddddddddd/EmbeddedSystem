# Keil uVision project IndustrialEmbedded-Boot.uvprojx, settings and files
target IndustrialEmbedded_Boot (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: GD32F470VE GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.3.5.0
  cpu: IRAM(0x20000000,0x030000) IRAM2(0x10000000,0x010000) IROM(0x08000000,0x080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(25000000) ELITTLE
  output: IndustrialEmbedded-Boot
  AfterMake: D:\keil5\ARM\ARMCC\bin\fromelf.exe --bin -o "$L@L.bin" "#L"
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F470,NDEBUG
  c include: ..\Driver\CMSIS\GD\GD32F4xx\Include;..\Driver\CMSIS;..\Libraries\Include;..\App;..\BSP;..\Middleware\Protocol\inc;..\Common\inc;..\Bootloader\inc;..\Middleware\Ringbuffer\inc;..\Middleware\CLI\inc;..\Middleware\Protocol\inc;..\Middleware\FlashKV\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Startup
    ../Driver/CMSIS/GD/GD32F4xx/Source/ARM/: startup_gd32f450_470.s
  group CMSIS
    ../Driver/CMSIS/GD/GD32F4xx/Source/: system_gd32f4xx.c
  group Libraries
    ../Libraries/Source/: gd32f4xx_adc.c gd32f4xx_can.c gd32f4xx_crc.c gd32f4xx_ctc.c gd32f4xx_dac.c gd32f4xx_dbg.c gd32f4xx_dci.c gd32f4xx_dma.c gd32f4xx_enet.c gd32f4xx_exmc.c gd32f4xx_exti.c gd32f4xx_fmc.c gd32f4xx_fwdgt.c gd32f4xx_gpio.c gd32f4xx_i2c.c gd32f4xx_ipa.c gd32f4xx_iref.c gd32f4xx_misc.c gd32f4xx_pmu.c gd32f4xx_rcu.c gd32f4xx_rtc.c gd32f4xx_sdio.c gd32f4xx_spi.c gd32f4xx_syscfg.c gd32f4xx_timer.c gd32f4xx_tli.c gd32f4xx_trng.c gd32f4xx_usart.c gd32f4xx_wwdgt.c
  group BSP
    ../BSP/: board_config.h board_gpio.c board_spi_flash.c board_internal_flash.c
  group Common
    ../Common/src/: common_crc.c systick.c upgrade_serialization.c
    ../Common/inc/: common_flash_layout.h common_reset_contract.h
  group Bootloader/src
    ../Bootloader/src/: boot_jump.c boot_main.c gd32f4xx_it.c boot_upgrade_meta.c boot_app_image.c
  group Middleware
    ../Middleware/CLI/src/: cli.c
    ../Middleware/Protocol/src/: modbus_rtu.c protocol_frame.c
    ../Middleware/Ringbuffer/src/: ringbuffer.c
    ../Middleware/FlashKV/src/: flash_kv.c
